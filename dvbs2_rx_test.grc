options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs2_rx_test
    output_language: python
    title: DVB-S2 Receiver Test
  states: {}

blocks:
- name: center_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:1,0,1,1
    label: Center
    start: '-100'
    step: '1'
    stop: '0'
    value: '0'
  states: {}
- name: lnb_freq
  id: variable
  parameters:
    value: 9750e6
  states: {}
- name: lower_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:2,0,1,1
    label: Lower
    start: '-100'
    step: '1'
    stop: '0'
    value: '0'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: tx_freq + lnb_freq
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '333000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '1001000000'
  states: {}
- name: upper_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,1
    label: Upper
    start: '-100'
    step: '1'
    stop: '0'
    value: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-500000'
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: '500000'
    sample_rate: samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbheader_bb_0_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbheader_bb_0_0_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0_0_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0_0_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0_0_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0_0_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_modulator_bc_0_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_modulator_bc_0_0_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_physical_cc_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_OFF
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_physical_cc_0_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_OFF
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_physical_cc_0_0_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_OFF
    rate1: C1_2
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '37'
    bandwidth: '1000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(tx_freq)
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf
    bb_gain0: '0'
    freq0: tx_freq
    gain0: '0'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate / (symbol_rate * 2)
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate / (symbol_rate * 2)
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_1
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate / (symbol_rate * 2)
    type: ccf
  states: {}
- name: pipe_source_0
  id: pipe_source
  parameters:
    command: ffmpeg -stream_loop -1 -i  waves.ts -c copy -f mpegts -muxrate 329289 -streamid 0:256 -pcr_period 40 -pat_period 0.4 -metadata service_provider="Test" -metadata service_name="333k QPSK 1/2 @ RF" -
    out_type: byte
    out_vlen: '1'
  states: {}
- name: pipe_source_0_0
  id: pipe_source
  parameters:
    command: ffmpeg -stream_loop -1 -i  particles.ts -c copy -f mpegts -muxrate 329289 -streamid 0:256 -pcr_period 40 -pat_period 0.4 -metadata service_provider="Test" -metadata service_name="333k QPSK 1/2 @ RF - 500kHz" -
    out_type: byte
    out_vlen: '1'
  states: {}
- name: pipe_source_0_0_0
  id: pipe_source
  parameters:
    command: ffmpeg -stream_loop -1 -i  tunnel.ts -c copy -f mpegts -muxrate 329289 -streamid 0:256 -pcr_period 40 -pat_period 0.4 -metadata service_provider="Test" -metadata service_name="333k QPSK 1/2 @ RF + 500kHz" -
    out_type: byte
    out_vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: rx_freq
    fftsize: '512'
    gui_hint: 0,0,10,1
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    decim: '1'
    gain: pow(10, center_gain/20)
    ntaps: taps
    samp_rate: 2*symbol_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    decim: '1'
    gain: pow(10, lower_gain/20)
    ntaps: taps
    samp_rate: symbol_rate*2
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    decim: '1'
    gain: pow(10, upper_gain/20)
    ntaps: taps
    samp_rate: symbol_rate*2
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 10,0,1,1
    label0: Channel Gains
    num_tabs: '1'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_add_xx_0, '2']
- [blocks_freqshift_cc_0_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbheader_bb_0_0, '0', dtv_dvb_bbscrambler_bb_0_0, '0']
- [dtv_dvb_bbheader_bb_0_0_0, '0', dtv_dvb_bbscrambler_bb_0_0_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0_0, '0', dtv_dvb_bch_bb_0_0, '0']
- [dtv_dvb_bbscrambler_bb_0_0_0, '0', dtv_dvb_bch_bb_0_0_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_bch_bb_0_0, '0', dtv_dvb_ldpc_bb_0_0, '0']
- [dtv_dvb_bch_bb_0_0_0, '0', dtv_dvb_ldpc_bb_0_0_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [dtv_dvb_ldpc_bb_0_0, '0', dtv_dvbs2_interleaver_bb_0_0, '0']
- [dtv_dvb_ldpc_bb_0_0_0, '0', dtv_dvbs2_interleaver_bb_0_0_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_interleaver_bb_0_0, '0', dtv_dvbs2_modulator_bc_0_0, '0']
- [dtv_dvbs2_interleaver_bb_0_0_0, '0', dtv_dvbs2_modulator_bc_0_0_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', dtv_dvbs2_physical_cc_0, '0']
- [dtv_dvbs2_modulator_bc_0_0, '0', dtv_dvbs2_physical_cc_0_0, '0']
- [dtv_dvbs2_modulator_bc_0_0_0, '0', dtv_dvbs2_physical_cc_0_0_0, '0']
- [dtv_dvbs2_physical_cc_0, '0', root_raised_cosine_filter_0, '0']
- [dtv_dvbs2_physical_cc_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [dtv_dvbs2_physical_cc_0_0_0, '0', root_raised_cosine_filter_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_add_xx_0, '1']
- [pfb_arb_resampler_xxx_0_0, '0', blocks_freqshift_cc_0, '0']
- [pfb_arb_resampler_xxx_0_1, '0', blocks_freqshift_cc_0_0, '0']
- [pipe_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [pipe_source_0_0, '0', dtv_dvb_bbheader_bb_0_0, '0']
- [pipe_source_0_0_0, '0', dtv_dvb_bbheader_bb_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [root_raised_cosine_filter_0_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [root_raised_cosine_filter_0_0_0, '0', pfb_arb_resampler_xxx_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
